# Keil uVision project BLµE RTOS.uvproj, settings and files
target BLµE RTOS (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: RTOS
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: RTOSmain.c
    ./asm/: Functions.s startup.s
    ./cfiles/: genInit.c Task.c Semaphore.c Flags.c Mailbox.c
  group Dependencies
    ./driverlib/: gpio.c sysctl.c interrupt.c systick.c cpu.c uart.c
    ./utils/: uartstdio.c
